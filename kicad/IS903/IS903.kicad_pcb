# Repository prashant87/IS903

## KiCad design kicad/IS903/IS903.kicad_pcb

Parts:
C1, C2, C11: 0.1uF; C_0402_1005Metric
C3: 0.01uF; C_0402_1005Metric
C4: 10uF; C_0402_1005Metric
C5, C7: 4.7uF; C_0402_1005Metric
C6: 1uF; C_0402_1005Metric
C8: 20PF; C_0402_1005Metric
C9: 10uF; C_0603_1608Metric
C10, C12: 20pF/6pF; C_0402_1005Metric
D1: LED_0603; C_0603_1608Metric
J1: USB3_A; USB3_A_Plug_Wuerth_692112030100_Horizontal
L1: 4.7uH; C_0603_1608Metric
R1: 453K; R_0402_1005Metric
R2, R3: 100K; R_0402_1005Metric
R4, R5, R6, R7, R8: 0R; R_0402_1005Metric
R9: 330R; R_0402_1005Metric
U1: IS903_QFN64_8*8
U2: EML3020; SOT-23-5
U3: EMP8733-1.2; SOT-23
U4, U5: NAND_BGA152
Y1: 30MHZ 2520; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+1V2: C4.2, U1.6, U1.29, U1.41, U1.56, U3.2 (VOUT)
+3V3: C6.1, C7.1, C8.1, C9.2, L1.1, R1.1, R9.1, U1.14, U1.24, U1.38, U1.51, U1.63, U3.3 (VIN), U4.D3, U4.D4, U4.D8, U4.D10, U4.D11, U4.G4, U4.G10, U4.J4, U4.J10, U4.L4, U4.L10, U4.P3, U4.P4, U4.P6, U4.P10, U4.P11, U5.D3, U5.D4, U5.D8, U5.D10, U5.D11, U5.G4, U5.G10, U5.J4, U5.J10, U5.L4, U5.L10, U5.P3, U5.P4, U5.P6, U5.P10, U5.P11
/DM: J1.2 (D-), U1.37
/DP: J1.3 (D+), U1.36
/F0_ALE: U1.13, U4.L9, U5.G5
/F0_CE0n: U1.20, U4.K5
/F0_CE1n: U1.21, U4.K6
/F0_CE2n: R4.2, U1.22, U5.H9
/F0_CE3n: R5.2, U1.23, U5.H8
/F0_CLE: U1.12, U4.L8, U5.G6
/F0_DQS: U1.46, U4.N8, U5.E6
/F0_IO0: U1.47, U4.M11, U5.F3
/F0_IO1: U1.48, U4.M10, U5.F4
/F0_IO2: U1.49, U4.N10, U5.E4
/F0_IO3: U1.50, U4.P9, U5.D5
/F0_IO4: U1.52, U4.P5, U5.D9
/F0_IO5: U1.53, U4.N4, U5.E10
/F0_IO6: U1.54, U4.M4, U5.F10
/F0_IO7: U1.55, U4.M3, U5.F11
/F0_REn: U1.11, U4.N6, U5.E8
/F0_WEn: U1.10, U4.M6, U5.F8
/F1_ALE: U1.18, U4.G5, U5.L9
/F1_CE0n: U1.25, U4.H9
/F1_CE1n: U1.26, U4.H8
/F1_CE2n: R8.1, U1.27, U5.K5
/F1_CE3n: R7.1, U1.28, U5.K6
/F1_CLE: U1.17, U4.G6, U5.L8
/F1_DQS: U1.57, U4.E6, U5.N8
/F1_IO0: U1.58, U4.F3, U5.M11
/F1_IO1: U1.59, U4.F4, U5.M10
/F1_IO2: U1.60, U4.E4, U5.N10
/F1_IO3: U1.61, U4.D5, U5.P9
/F1_IO4: U1.62, U4.D9, U5.P5
/F1_IO5: U1.64, U4.E10, U5.N4
/F1_IO6: U1.1, U4.F10, U5.M4
/F1_IO7: U1.2, U4.F11, U5.M3
/F1_REn: U1.16, U4.E8, U5.N6
/F1_WEn: U1.15, U4.F8, U5.M6
/F_RBn: U4.J5, U4.J6, U4.J8, U4.J9, U5.J5, U5.J6, U5.J8, U5.J9
/F_WPn: U1.19, U4.H5, U4.K9, U5.H5, U5.K9
/LED_0: D1.1 (K), U1.9
/MODE_1: R3.2, U1.45
/OSCIN: C10.2, U1.35, Y1.1
/OSCIO: C12.2, U1.34, Y1.3
/RST: C11.2, U1.8
/SSRXM: J1.5 (SSRX-), U1.42
/SSRXP: J1.6 (SSRX+), U1.43
/SSTXM: C1.1, U1.39
/SSTXP: C2.1, U1.40
/VSS1: R6.2, U4.H11, U4.K3, U4.K10
GND: C3.2, C4.1, C5.2, C6.2, C7.2, C9.1, C10.1, C11.1, C12.1, J1.4 (GND), J1.7 (DRAIN), J1.10 (SHIELD), R2.1, R3.1, R6.1, U1.3, U1.4, U1.7, U1.44, U1.65, U2.5 (GND), U2.7 (GND), U3.1 (GND), U4.D6, U4.E3, U4.E5, U4.E9, U4.E11, U4.G3, U4.G11, U4.J3, U4.J11, U4.L3, U4.L11, U4.N3, U4.N5, U4.N9, U4.N11, U4.P8, U5.D6, U5.E3, U5.E5, U5.E9, U5.E11, U5.G3, U5.G11, U5.J3, U5.J11, U5.L3, U5.L11, U5.N3, U5.N5, U5.N9, U5.N11, U5.P8, Y1.2, Y1.4
unnamed: C1.2, J1.8 (SSTX-)
unnamed: C2.2, J1.9 (SSTX+)
unnamed: C8.2, R1.2, R2.2, U2.6 (VFB)
unnamed: D1.2 (A), R9.2
unnamed: L1.2, U2.4 (SW)
unnamed: R4.1, U4.L5
unnamed: R5.1, U4.L6
unnamed: R7.2, U4.G8
unnamed: R8.2, U4.G9

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
Board: 4 copper layers, 33.0 x 14.0 mm, 31 parts (13 on the bottom side), 62 nets.

Other parts of the board:
F1: Fuse; Fuse_0603_1608Metric

## Commit log

2020-07-09 create
2020-07-14 2020.7.14
2020-07-21 finish sch
2020-07-22 完成PCB布局
2020-07-23 2020.7.23
2020-07-24 第一次布线失败，暂时放弃
2020-07-30 2020.7.30
2020-08-01 使用AD重新绘制原理图
2020-08-03 完成指定封装，基本PCB布局
2020-08-05 完成基本布线，剩余电源
2020-08-06 完成布线，待检查漏线
2020-08-07 完成全部布线，完成漏线检查
2020-08-07 添加丝印
2020-08-16 修改丝印大小，位置，修改USB焊盘
2020-08-20 添加量产工具，整理参考资料
2020-08-23 添加测试工具
